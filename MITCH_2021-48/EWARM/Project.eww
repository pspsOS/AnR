<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MITCH_2021-48.ewp</path>
  </project>
  <batchBuild />
</workspace>
